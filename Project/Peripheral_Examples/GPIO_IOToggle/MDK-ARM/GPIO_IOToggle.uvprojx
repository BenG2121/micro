# Keil uVision project GPIO_IOToggle.uvprojx, settings and files
target GPIO_IOToggle (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO_IOToggle
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F30X,
  c include: .\..\;.\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include;.\..\..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc;.\..\..\..\..\Utilities\STM32F3_Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group MDK-ARM
    ./../../../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
  group STM32F3-Discovery
    ./../../../../Utilities/STM32F3_Discovery/: stm32f3_discovery.c
  group STM32F30x_StdPeriph_Driver
    ./../../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_rcc.c
    ../../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_syscfg.c stm32f30x_exti.c
  group User
    ./../: main.c stm32f30x_it.c system_stm32f30x.c
software components: CMSIS:CORE 4.1.0
